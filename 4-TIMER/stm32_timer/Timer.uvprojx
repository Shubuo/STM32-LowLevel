# Keil uVision project Timer.uvprojx, settings and files
target Simulator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Timer
  c flags: Optim=1
  c include: .\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup Code
    ./: STM32F10x.s
  group Initialisation
    ./: STM32_Init.c
  group Source
    ./: Timer.c
    ./STM32F10x_StdPeriph_Driver/inc/: stm32f10x_lib.h
    ./CMSIS/inc/: system_stm32f2xx.h core_cm3.h core_cm3.c
  group Documentation
    ./: Abstract.txt
target MCBSTM32 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: Timer
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F1XX, HSE_VALUE = 8000000
  c include: ..\stm32_timer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
