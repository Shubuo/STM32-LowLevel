# Keil uVision project stm32F.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: stm32F +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Burak_STM32
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source
    ./: MAIN.C exs03.c delay.c lcd.c gpio_by.c
  group Header
    ./: exs03.h delay.h lcd.h gpio_by.h
software components: CMSIS:CORE 5.0.1, Device:DMA 1.2, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:BKP 3.5.0, Device:StdPeriph Drivers:CAN 3.5.0, Device:StdPeriph Drivers:CEC 3.5.0, Device:StdPeriph Drivers:CRC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DBGMCU 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:FSMC 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:IWDG 3.5.0, Device:StdPeriph Drivers:PWR 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SDIO 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0, Device:StdPeriph Drivers:WWDG 3.5.0
