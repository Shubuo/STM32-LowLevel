# Keil uVision project Project.uvproj, settings and files
target EXS03-F103-SDCARD (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F100ZE STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: EXS03-F103-SDCARD +hex
  c flags: Optim=1 oTime=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\EXPKITS;..\spi_msd;..\ff9\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Startup
    ../src/: startup_stm32f10x_md.s
  group CMSIS
    ../src/: system_stm32f10x.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SD Driver
    ../spi_msd/: SPI_MSD_Driver.c
  group FATFS
    ../ff9/src/: diskio.c ff.c
  group User
    ../../EXPKITS/: exs03.c lcd.c delay.c
    ../src/: main.c stm32f10x_it.c
  group Doc
    ./: readme.txt
