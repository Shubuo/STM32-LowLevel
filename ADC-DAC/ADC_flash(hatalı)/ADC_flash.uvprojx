# Keil uVision project ADC_flash.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103R8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC_flash
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\ADC_flash;.\stm32_unict_lib\inc;.\stm32_unict_lib\src
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: adc_flash.c
  group Santoro
    ./stm32_unict_lib/src/: adc.c console.c display.c gpio.c syscalls.c system_init.c systick.c timers.c usart.c
    ./stm32_unict_lib/inc/: stm32_unict_lib.h adc.h console.h defines.h display.h gpio.h systick.h timers.h usart.h watchdog.h
software components: CMSIS:CORE 5.1.1, Device:Startup 1.0.0
