# Keil uVision project Blinky.uvprojx, settings and files
target STM32F100RB Flash (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x2000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Blinky +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_LD_VL
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Startup
    ./: startup_stm32f10x_ld_vl.s system_stm32f10x.c
  group Source Files
    ./: Blinky.c
  group Documentation
    ./: Abstract.txt
target STM32F100RB RAM (ARM-ADS)
  device: STM32F100RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: as above
  output: Blinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_LD_VL VECT_TAB_SRAM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x2000
software components: CMSIS:CORE 5.0.1
